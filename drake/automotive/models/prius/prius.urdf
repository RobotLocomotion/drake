Commit message: urdf model body inertia update

File: drake/automotive/models/prius/prius.urdf (robot description, URDF)
Before this commit: robot prius_1, 14 links, 13 joints
Links:
- link body: mass 5.42794 -> 54.2794
