Commit message: Robotiq box now has accurate robotiq mass

File: examples/Atlas/urdf/robotiq_box.urdf (robot description, URDF)
Before this commit: robot box_hand, 1 links, 0 joints
Links:
- link box_hand_1: mass 2.5 -> 1.3002
